# Keil uVision project Taurus_IMU.uvprojx, settings and files
target Taurus_IMU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F302K8Ux STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Taurus_IMU +hex
  AfterMake: fromelf --bin --output .\Taurus_IMU.bin .\Taurus_IMU\Taurus_IMU.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302x8,USE_HAL_DRIVER,STM32F302x8,ARM_MATH_CM4,__FPU_PRESENT=1
  c include: ../Inc;    ../Drivers/STM32F3xx_HAL_Driver/Inc;    ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;    ../Drivers/CMSIS/Include;    ..\App;    ..\bsp;    ..\mathlib;    ..\dsp\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f302x8.s
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_can.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c stm32f3xx_hal_timebase_tim.c
  group Application/UserBsp
    ../bsp/: bsp_spi.c bsp_iic.c bsp_uart.c bsp_can.c bsp_delay.c bsp_bmi088.c bsp_imu.c bsp_JY901.c bsp_ist8310.c bsp_flash.c
  group Application/AppCtrl
    ../App/: BMI088_Read.c IST8310_Read.c IMU_AHRSupdate.c Comm_Task.c Status_Task.c
  group Application/Mathlib
    ../mathlib/: Filter.c Calibration.c data_processing.c KalmanFilter.c pid.c
  group Application/Dsp
    ../dsp/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.3.0
